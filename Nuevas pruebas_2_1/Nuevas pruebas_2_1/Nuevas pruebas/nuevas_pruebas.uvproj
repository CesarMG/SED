# Keil uVision project nuevas_pruebas.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: nuevas_pruebas
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Código
    ./: main.c i2c_lpc17xx.c configuraciones.c funciones.c interrupciones.c uart.c
  group Pantalla
    ./: font.c lcddriver.c lpc17xx_clkpwr.c lpc17xx_gpio.c
target miniDK2 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: nuevas_pruebas
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
